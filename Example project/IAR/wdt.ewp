# IAR project wdt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\..\STM8S_StdPeriph_Driver\inc; ..\..\ws2812b; ..
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: wdt.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../: main.c stm8s_it.c
  group stm8s_spl
    ../../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c
  group ws2812b
    ../../ws2812b/: ws2812b_conf.h ws2812b_fx.c ws2812B_fx.h ws2812b_LLD.c ws2812b_LLD.h
